<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\P20M_STM32F103RC.ewp</path>
  </project>
  <batchBuild/>
</workspace>


