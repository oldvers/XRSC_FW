# Keil uVision project NewRoadSign.uvproj, settings and files
target NewRoadSign (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NewRoadSign
  AfterMake: fromelf --i32 --output=.\exe\NewRoadSign.hex .\out\NewRoadSign.axf
  AfterMake: fromelf -c --output=.\lst\FullListing.txt .\out\NewRoadSign.axf
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD
  c include: ..\src;..\src\CMSIS\Include;..\src\CMSIS\Device\ST\STM32F10x\Include;..\src\RoadSign;..\src\RTOS;..\src\WiFi
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ../src/: main.c gpio.h leds.h types.h uniquedevid.h main_task_wifi.h main_task_wifi.c main_task_roadsign.h main_task_roadsign.c adc.h adc.c
  group RoadSign
    ../src/RoadSign/: rsProcessing.h rsUnpacking.h rsUnpacking.c rsImageRefreshing.h rsImageRefreshing.c p20mrgb.h p20mrgb.c
  group CMSIS
    ../src/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
    ../src/CMSIS/Device/ST/STM32F10x/Include/: stm32f10x.h system_stm32f10x.h
    ../src/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
    ../src/: interrupts.h interrupts.c
  group RTOS
    ../src/RTOS/: RTX_Conf_CM.c
  group WiFi
    ../src/WiFi/: uart.h uart.c wifi.h wifi.c
