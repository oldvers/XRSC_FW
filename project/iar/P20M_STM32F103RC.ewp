# IAR project P20M_STM32F103RC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_MD
  ICCARM.CCIncludePath2: ..\..\src\RoadSign; ..\..\src; ..\..\src\CMSIS\Include; ..\..\src\CMSIS\Device\ST\STM32F10x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Main
    ../../src/: gpio.h types.h
    ./: main.c
  group RoadSign
    ../../src/RoadSign/: p20mrgb.c p20mrgb.h rsImageRefreshing.c rsImageRefreshing.h rsProcessing.h rsUnpacking.c rsUnpacking.h
